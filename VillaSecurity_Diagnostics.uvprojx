# Keil uVision project VillaSecurity_Diagnostics.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VillaSecurity_Diagnostics +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Bsp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./App/: main_diagnostics.c sensors.c alarm.c
    ./Bsp/: board.c oled.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
